## cw3/package/buggy/Config.in
```kconfig
config BR2_PACKAGE_BUGGY
	bool "buggy"
	help
	  Intentionally buggy applications

	  http://nowhere.com
```
